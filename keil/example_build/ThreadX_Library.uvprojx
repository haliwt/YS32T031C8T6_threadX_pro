# Keil uVision project ThreadX_Library.uvprojx, settings and files
target ThreadX_Library_Project (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: YS32T031C8T6 YSpring
  pack: YSPRING.YS32T031.0.0.28
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0xF000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: YS32T031C8T6_HEX +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\inc;..\src;..\..\User\inc;..\..\User\src;..\..\Libraries\YS32T031_StdPeriph_Driver\inc;..\..\Libraries\YS32T031_StdPeriph_Driver\src;..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Device\YS32T031\Include;..\..\Libraries\CMSIS\Device\YS32T031\Source;..\..\Libraries\CMSIS\Device\YS32T031\Source\ARM;..\..\Bsp\inc;..\..\Bsp\src
  asm define: TX_ENABLE_WFI
  asm misc: --cpreproc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0xf000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group User
    ../../User/src/: adc.c display.c iwdg.c key.c main.c system_init.c tim.c tm1639.c touch_circle.c touch_silder.c uart.c ys32t031_it.c ys32t031_tsc_init.c ys32t031_tsc_lib_3.00.c tx_initialize_low_level.s
    ../src/: tx_thread_context_restore.s tx_thread_context_save.s tx_thread_interrupt_control.s tx_thread_interrupt_disable.s tx_thread_interrupt_restore.s tx_thread_schedule.s tx_thread_stack_build.s tx_thread_system_return.s tx_timer_interrupt.s
  group Driver
    ../../Libraries/YS32T031_StdPeriph_Driver/src/: delay.c ys32t031_adc.c ys32t031_comp.c ys32t031_crc.c ys32t031_dbgmcu.c ys32t031_dma.c ys32t031_exti.c ys32t031_flash.c ys32t031_gpio.c ys32t031_i2c.c ys32t031_iwdg.c ys32t031_led.c ys32t031_lptim.c ys32t031_misc.c ys32t031_pwr.c ys32t031_rcc.c ys32t031_rtc.c ys32t031_spi.c ys32t031_syscfg.c ys32t031_tim.c ys32t031_tsc.c ys32t031_uart.c ys32t031_vrefbuf.c ys32t031_wwdg.c
  group CMSIS
    ../../Libraries/CMSIS/Device/YS32T031/Source/: system_ys32t031.c
    ../../Libraries/CMSIS/Device/YS32T031/Source/ARM/: startup_ys32t031.s
  group Bsp
    ../../Bsp/src/: bsp.c bsp_cmd_link.c bsp_esp8266.c bsp_key.c bsp_led.c bsp_mqtt_iot.c bsp_peripheral.c bsp_power.c bsp_usart_wifi.c bsp_xdp.c bsp_threadx.c bsp_smg.c bsp_tm1639.c bsp_sensor.c bsp_ntc.c
  group inc
    ../inc/: tx_api.h tx_block_pool.h tx_byte_pool.h tx_event_flags.h tx_initialize.h tx_mutex.h tx_port.h tx_queue.h tx_semaphore.h tx_thread.h tx_timer.h tx_trace.h tx_user_sample.h tx_user.h
  group src
    ../src/: tx_block_allocate.c tx_block_pool_cleanup.c tx_block_pool_create.c tx_block_pool_delete.c tx_block_pool_info_get.c tx_block_pool_initialize.c tx_block_pool_performance_info_get.c tx_block_pool_performance_system_info_get.c tx_block_pool_prioritize.c tx_block_release.c tx_byte_allocate.c tx_byte_pool_cleanup.c tx_byte_pool_create.c tx_byte_pool_delete.c tx_byte_pool_info_get.c tx_byte_pool_initialize.c tx_byte_pool_performance_info_get.c tx_byte_pool_performance_system_info_get.c tx_byte_pool_prioritize.c tx_byte_pool_search.c tx_byte_release.c tx_event_flags_cleanup.c tx_event_flags_create.c tx_event_flags_delete.c tx_event_flags_get.c tx_event_flags_info_get.c tx_event_flags_initialize.c tx_event_flags_performance_info_get.c tx_event_flags_performance_system_info_get.c tx_event_flags_set.c tx_event_flags_set_notify.c tx_initialize_high_level.c tx_initialize_kernel_enter.c tx_initialize_kernel_setup.c tx_misra.c tx_mutex_cleanup.c tx_mutex_create.c tx_mutex_delete.c tx_mutex_get.c tx_mutex_info_get.c tx_mutex_initialize.c tx_mutex_performance_info_get.c tx_mutex_performance_system_info_get.c tx_mutex_prioritize.c tx_mutex_priority_change.c tx_mutex_put.c tx_queue_cleanup.c tx_queue_create.c tx_queue_delete.c tx_queue_flush.c tx_queue_front_send.c tx_queue_info_get.c tx_queue_initialize.c tx_queue_performance_info_get.c tx_queue_performance_system_info_get.c tx_queue_prioritize.c tx_queue_receive.c tx_queue_send.c tx_queue_send_notify.c tx_semaphore_ceiling_put.c tx_semaphore_cleanup.c tx_semaphore_create.c tx_semaphore_delete.c tx_semaphore_get.c tx_semaphore_info_get.c tx_semaphore_initialize.c tx_semaphore_performance_info_get.c tx_semaphore_performance_system_info_get.c tx_semaphore_prioritize.c tx_semaphore_put.c tx_semaphore_put_notify.c tx_thread_create.c tx_thread_delete.c tx_thread_entry_exit_notify.c tx_thread_identify.c tx_thread_info_get.c tx_thread_initialize.c tx_thread_performance_info_get.c tx_thread_performance_system_info_get.c tx_thread_preemption_change.c tx_thread_priority_change.c tx_thread_relinquish.c tx_thread_reset.c tx_thread_resume.c tx_thread_shell_entry.c tx_thread_sleep.c tx_thread_stack_analyze.c tx_thread_stack_error_handler.c tx_thread_stack_error_notify.c tx_thread_suspend.c tx_thread_system_preempt_check.c tx_thread_system_resume.c tx_thread_system_suspend.c tx_thread_terminate.c tx_thread_time_slice.c tx_thread_time_slice_change.c tx_thread_timeout.c tx_thread_wait_abort.c tx_time_get.c tx_time_set.c tx_timer_activate.c tx_timer_change.c tx_timer_create.c tx_timer_deactivate.c tx_timer_delete.c tx_timer_expiration_process.c tx_timer_info_get.c tx_timer_initialize.c tx_timer_performance_info_get.c tx_timer_performance_system_info_get.c tx_timer_system_activate.c tx_timer_system_deactivate.c tx_timer_thread_entry.c tx_trace_buffer_full_notify.c tx_trace_disable.c tx_trace_enable.c tx_trace_event_filter.c tx_trace_event_unfilter.c tx_trace_initialize.c tx_trace_interrupt_control.c tx_trace_isr_enter_insert.c tx_trace_isr_exit_insert.c tx_trace_object_register.c tx_trace_object_unregister.c tx_trace_user_event_insert.c txe_block_allocate.c txe_block_pool_create.c txe_block_pool_delete.c txe_block_pool_info_get.c txe_block_pool_prioritize.c txe_block_release.c txe_byte_allocate.c txe_byte_pool_create.c txe_byte_pool_delete.c txe_byte_pool_info_get.c txe_byte_pool_prioritize.c txe_byte_release.c txe_event_flags_create.c txe_event_flags_delete.c txe_event_flags_get.c txe_event_flags_info_get.c txe_event_flags_set.c txe_event_flags_set_notify.c txe_mutex_create.c txe_mutex_delete.c txe_mutex_get.c txe_mutex_info_get.c txe_mutex_prioritize.c txe_mutex_put.c txe_queue_create.c txe_queue_delete.c txe_queue_flush.c txe_queue_front_send.c txe_queue_info_get.c txe_queue_prioritize.c txe_queue_receive.c txe_queue_send.c txe_queue_send_notify.c txe_semaphore_ceiling_put.c txe_semaphore_create.c txe_semaphore_delete.c txe_semaphore_get.c txe_semaphore_info_get.c txe_semaphore_prioritize.c txe_semaphore_put.c txe_semaphore_put_notify.c txe_thread_create.c txe_thread_delete.c txe_thread_entry_exit_notify.c txe_thread_info_get.c txe_thread_preemption_change.c txe_thread_priority_change.c txe_thread_relinquish.c txe_thread_reset.c txe_thread_resume.c txe_thread_suspend.c txe_thread_terminate.c txe_thread_time_slice_change.c txe_thread_wait_abort.c txe_timer_activate.c txe_timer_change.c txe_timer_create.c txe_timer_deactivate.c txe_timer_delete.c txe_timer_info_get.c
